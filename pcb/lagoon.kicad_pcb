# Repository digitarhythm/Lagoon

File README.md:

# TReK Lagoon

- TReK Lagoon KiCAD Project

[Firmware repository](https://github.com/digitarhythm/vial-qmk/tree/digitarhythm/keyboards/trek/lagoon)

## KiCad design pcb/lagoon.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45: D; Diode_SMD
J2, J4, J5, J7: Conn_01x01; m2_Spacer_Hole_EdgeCuts
J3, J6: Conn_01x01; m2_Screw_Hole_EdgeCuts
J8, J9, J10, J11, J12, J13, J14, J15, J16, J17: Conn_01x01; m2_Screw_Hole_Fab
L1, L2, L3, L4, L5, L6, L7, L8, L9, L10, L11, L12, L13, L14, L15, L16, L17, L18, L19, L20, L21, L22, L23, L24, L25, L26, L27, L28, L29, L30, L31, L32, L33, L34, L35, L36, L37, L38, L39, L40, L41: SK6812MINI; LED_SK6812MINI-E_BL
SW1, SW2, SW3, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43: SW_PUSH; Lofree_Hotswap_1u
SW4, SW23, SW44: RotaryEncoder_Switch; RotaryEncoder_EC12E
U2: rp2040-zero; rp2040-zero(pattern only)

Connections:
Col0: SW1.1, SW2.1, SW3.1, SW4.S2, SW24.1, SW25.1, SW26.1, U2.2 (1)
Col1: SW5.1, SW6.1, SW7.1, SW8.1, SW27.1, SW28.1, SW29.1, SW30.1, U2.3 (2)
Col2: SW9.1, SW10.1, SW11.1, SW12.1, SW31.1, SW32.1, SW33.1, SW34.1, U2.4 (3)
Col3: SW13.1, SW14.1, SW15.1, SW16.1, SW35.1, SW36.1, SW37.1, SW38.1, U2.5 (4)
Col4: SW17.1, SW18.1, SW19.1, SW39.1, SW40.1, SW41.1, U2.6 (5)
Col5: SW20.1, SW21.1, SW22.1, SW23.S2, SW42.1, SW43.1, SW44.S2, U2.7 (6)
GND: J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, L1.2 (VSS), L2.2 (VSS), L3.2 (VSS), L4.2 (VSS), L5.2 (VSS), L6.2 (VSS), L7.2 (VSS), L8.2 (VSS), L9.2 (VSS), L10.2 (VSS), L11.2 (VSS), L12.2 (VSS), L13.2 (VSS), L14.2 (VSS), L15.2 (VSS), L16.2 (VSS), L17.2 (VSS), L18.2 (VSS), L19.2 (VSS), L20.2 (VSS), L21.2 (VSS), L22.2 (VSS), L23.2 (VSS), L24.2 (VSS), L25.2 (VSS), L26.2 (VSS), L27.2 (VSS), L28.2 (VSS), L29.2 (VSS), L30.2 (VSS), L31.2 (VSS), L32.2 (VSS), L33.2 (VSS), L34.2 (VSS), L35.2 (VSS), L36.2 (VSS), L37.2 (VSS), L38.2 (VSS), L39.2 (VSS), L40.2 (VSS), L41.2 (VSS), SW4.C, SW23.C, SW44.C, U2.22 (GND)
LED: L1.3 (DIN), U2.1 (0)
LEDVCC: D45.1 (K), L1.4 (VDD), L2.4 (VDD), L3.4 (VDD), L4.4 (VDD), L5.4 (VDD), L6.4 (VDD), L7.4 (VDD), L8.4 (VDD), L9.4 (VDD), L10.4 (VDD), L11.4 (VDD), L12.4 (VDD), L13.4 (VDD), L14.4 (VDD), L15.4 (VDD), L16.4 (VDD), L17.4 (VDD), L18.4 (VDD), L19.4 (VDD), L20.4 (VDD), L21.4 (VDD), L22.4 (VDD), L23.4 (VDD), L24.4 (VDD), L25.4 (VDD), L26.4 (VDD), L27.4 (VDD), L28.4 (VDD), L29.4 (VDD), L30.4 (VDD), L31.4 (VDD), L32.4 (VDD), L33.4 (VDD), L34.4 (VDD), L35.4 (VDD), L36.4 (VDD), L37.4 (VDD), L38.4 (VDD), L39.4 (VDD), L40.4 (VDD), L41.4 (VDD)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.S1
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.S1
unnamed: D24.1 (K), SW24.2
unnamed: D25.1 (K), SW25.2
unnamed: D26.1 (K), SW26.2
unnamed: D27.1 (K), SW27.2
unnamed: D28.1 (K), SW28.2
unnamed: D29.1 (K), SW29.2
unnamed: D30.1 (K), SW30.2
unnamed: D31.1 (K), SW31.2
unnamed: D32.1 (K), SW32.2
unnamed: D33.1 (K), SW33.2
unnamed: D34.1 (K), SW34.2
unnamed: D35.1 (K), SW35.2
unnamed: D36.1 (K), SW36.2
unnamed: D37.1 (K), SW37.2
unnamed: D38.1 (K), SW38.2
unnamed: D39.1 (K), SW39.2
unnamed: D40.1 (K), SW40.2
unnamed: D41.1 (K), SW41.2
unnamed: D42.1 (K), SW42.2
unnamed: D43.1 (K), SW43.2
unnamed: D44.1 (K), SW44.S1
unnamed: L1.1 (DOUT), L2.3 (DIN)
unnamed: L2.1 (DOUT), L3.3 (DIN)
unnamed: L3.1 (DOUT), L4.3 (DIN)
unnamed: L4.1 (DOUT), L5.3 (DIN)
unnamed: L5.1 (DOUT), L6.3 (DIN)
unnamed: L6.1 (DOUT), L7.3 (DIN)
unnamed: L7.1 (DOUT), L8.3 (DIN)
unnamed: L8.1 (DOUT), L9.3 (DIN)
unnamed: L9.1 (DOUT), L10.3 (DIN)
unnamed: L10.1 (DOUT), L11.3 (DIN)
unnamed: L11.1 (DOUT), L12.3 (DIN)
unnamed: L12.1 (DOUT), L13.3 (DIN)
unnamed: L13.1 (DOUT), L14.3 (DIN)
unnamed: L14.1 (DOUT), L15.3 (DIN)
unnamed: L15.1 (DOUT), L16.3 (DIN)
unnamed: L16.1 (DOUT), L17.3 (DIN)
unnamed: L17.1 (DOUT), L18.3 (DIN)
unnamed: L18.1 (DOUT), L19.3 (DIN)
unnamed: L19.1 (DOUT), L20.3 (DIN)
unnamed: L20.1 (DOUT), L21.3 (DIN)
unnamed: L21.1 (DOUT), L22.3 (DIN)
unnamed: L22.1 (DOUT), L23.3 (DIN)
unnamed: L23.1 (DOUT), L24.3 (DIN)
unnamed: L24.1 (DOUT), L25.3 (DIN)
unnamed: L25.1 (DOUT), L26.3 (DIN)
unnamed: L26.1 (DOUT), L27.3 (DIN)
unnamed: L27.1 (DOUT), L28.3 (DIN)
unnamed: L28.1 (DOUT), L29.3 (DIN)
unnamed: L29.1 (DOUT), L30.3 (DIN)
unnamed: L30.1 (DOUT), L31.3 (DIN)
unnamed: L31.1 (DOUT), L32.3 (DIN)
unnamed: L32.1 (DOUT), L33.3 (DIN)
unnamed: L33.1 (DOUT), L34.3 (DIN)
unnamed: L34.1 (DOUT), L35.3 (DIN)
unnamed: L35.1 (DOUT), L36.3 (DIN)
unnamed: L36.1 (DOUT), L37.3 (DIN)
unnamed: L37.1 (DOUT), L38.3 (DIN)
unnamed: L38.1 (DOUT), L39.3 (DIN)
unnamed: L39.1 (DOUT), L40.3 (DIN)
unnamed: L40.1 (DOUT), L41.3 (DIN)
RE01a: SW4.A, U2.20 (29)
RE01b: SW4.B, U2.19 (28)
RE02a: SW23.A, U2.18 (27)
RE02b: SW23.B, U2.17 (26)
RE03a: SW44.A, U2.16 (15)
RE03b: SW44.B, U2.15 (14)
Row0: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), D17.1 (K), D20.1 (K), D24.2 (A), D27.2 (A), D31.2 (A), D35.2 (A), D39.2 (A), D42.2 (A), U2.9 (8)
Row1: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), D18.1 (K), D21.1 (K), D25.2 (A), D28.2 (A), D32.2 (A), D36.2 (A), D40.2 (A), D43.2 (A), U2.10 (9)
Row2: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), D19.1 (K), D22.1 (K), D26.2 (A), D29.2 (A), D33.2 (A), D37.2 (A), D41.2 (A), U2.13 (12)
Row3: D4.1 (K), D8.1 (K), D12.1 (K), D16.1 (K), D23.1 (K), D30.2 (A), D34.2 (A), D38.2 (A), D44.2 (A), U2.14 (13)
VCC: D45.2 (A), U2.23 (5V)

Notes on the sheet:
Left hand block (Max 23 keys)
Screw(Don't delete it!)
Don't delete it!
Right hand block (Max 21 keys)
LED x 66
BLE Micro Pro

Board: 2 copper layers, 248.9 x 93.1 mm, 137 parts (1 on the bottom side), 104 nets.

Other parts of the board:
G000: LOGO
J4#2: Conn_01x01; m2_Spacer_Hole_EdgeCuts

## Commit log

2024-07-03 Update LICENSE
